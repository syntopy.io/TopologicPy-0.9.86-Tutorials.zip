Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: one_room.ifc
Time: 2026-10-16T12:00:00
Author: TopologicPy tutorials
Written by: TopologicPy tutorial fixture
Made in: TopologicPy

# IfcBuildingStorey, Ground Floor
In: Tutorial Building
Elevation: 0 m

# IfcSpace, Studio
In: Ground Floor
PredefinedType: INTERNAL; ElevationWithFlooring: 0 m
